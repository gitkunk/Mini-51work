# Keil uVision project Project.uvproj, settings and files
target 1632242111031_林剑威 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group User
    ./: main.c
  group Driver
    ../Driver/: Kunkunmv.c OneWire.c DS18B20.c ds1302.c Key.c Led.c Seg.c SPI.c iic.c
